# IAR project TIMER_PowerDown.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M051SAN series Nuvoton M058SAN series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M058S\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TIMER_PowerDown.bin
  ILINK.IlinkOutputFile: TIMER_PowerDown.out
  ILINK.IlinkIcfFile: TIMER_PowerDown.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M058S/Source/IAR/: startup_M058S.s
    ../../../../Library/Device/Nuvoton/M058S/Source/: system_M058S.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c timer.c uart.c
  group User
    ../: main.c
