# IAR project Template.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M051SAN series Nuvoton M058SAN series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\Library\Device\Nuvoton\M058S\Include; ..\..\..\Library\CMSIS\Include; ..\..\..\Library\StdDriver\inc; ..\..\..\Library\M051-LB_004\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.bin
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkIcfFile: M058S.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M058S/Source/IAR/: startup_M058S.s
    ../../../Library/Device/Nuvoton/M058S/Source/: system_M058S.c
  group Library
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group User
    ../: main.c
