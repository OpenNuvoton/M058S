# Keil uVision project ISP_I2C.uvproj, settings and files
target ISP_I2C (6160000::V6.16::ARMCLANG)
  device: M058SSAN Nuvoton
  cpu: IRAM(0x20000000-0x200007FF) IROM(0-0x07FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: ISP_I2C
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\Device\Nuvoton\M058S\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x800
  group CMSIS
    ../../../../Library/Device/Nuvoton/M058S/Source/: system_M058S.c
    ../../../../Library/Device/Nuvoton/M058S/Source/ARM/: startup_M058S.s
  group User
    ../: main.c FMC_USER.c ISP_USER.c targetdev.c i2c_transfer.c
